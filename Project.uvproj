# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: PRINTF_LARGE
  c include: .\src\inc;.\src\ui\Driver\Hardware_Driver;.\src\ui\Driver\Software_Driver;.\src\ui\OLED_UI;D:\APP\C51V961\C51\INC;D:\APP\C51V961\C51\INC\STC
  link misc: REMOVEUNUSED
  group app
    ./src/app/: main.c
  group ui
    ./src/ui/Driver/Software_Driver/: OLED.c OLED_Fonts.c
  group ui_framework
    ./src/ui/OLED_UI/: OLED_UI.c OLED_UI_Launcher.c OLED_UI_MenuData.c
  group driver
    ./src/ui/Driver/Hardware_Driver/: OLED_driver.c calendar.c EEPROM.c RTC.c timeedit.c IR_Remote.c OLED_UI_Driver.c
    ./src/lib/: stc_usb_cdc_8h_xdata.LIB
